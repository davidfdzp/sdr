options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: tutorial_two_3
    output_language: python
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 2e3
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: .5*freq
    step: '200'
    stop: 20*freq
    value: 5*freq
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: 32e3
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@1
    name: ''
    showports: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tab@0
    label1: ''
    name: ''
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: Time
    label1: Frequency
    num_tabs: '2'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
