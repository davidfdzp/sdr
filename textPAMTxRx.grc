options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: samples_per_symbol
  id: variable
  parameters:
    value: '8'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '0.5'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '0'
    type: float
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '0'
    type: byte
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /dev/pts/19
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: list(ord(i) for i in 'The quick brown fox...')
  states: {}
- name: digital_binary_slicer_fb_1
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: samples_per_symbol
    taps: '1'
    type: fff
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: samples_per_symbol
    taps: 1,1,1,1,1,1,1,1
    type: fff
  states: {}
- name: notebook
  id: notebook
  parameters:
    labels: '[''Tx signal scope'', ''Rx signal scope'']'
    style: wx.NB_TOP
  states: {}
- name: wxgui_scopesink2_0
  id: wxgui_scopesink2
  parameters:
    ac_couple: 'False'
    notebook: notebook, 0
    num_inputs: '1'
    samp_rate: samp_rate*samples_per_symbol
    t_scale: '0'
    title: Scope Plot
    trig_mode: wxgui.TRIG_MODE_AUTO
    type: float
    v_offset: '0'
    v_scale: '0'
    xy_mode: 'False'
    y_axis_label: Counts
  states: {}
- name: wxgui_scopesink2_0_0
  id: wxgui_scopesink2
  parameters:
    ac_couple: 'False'
    notebook: notebook,1
    num_inputs: '2'
    samp_rate: samp_rate*samples_per_symbol
    t_scale: '0'
    title: Scope Plot
    trig_mode: wxgui.TRIG_MODE_AUTO
    type: float
    v_offset: '0'
    v_scale: '0'
    xy_mode: 'False'
    y_axis_label: Counts
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_char_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_delay_0, '0', fir_filter_xxx_0, '0']
- [blocks_delay_0, '0', wxgui_scopesink2_0_0, '0']
- [blocks_delay_0_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_delay_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_char_to_float_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_vector_source_x_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [digital_binary_slicer_fb_1, '0', blocks_delay_0_0, '0']
- [fir_filter_xxx_0, '0', digital_binary_slicer_fb_1, '0']
- [fir_filter_xxx_0, '0', wxgui_scopesink2_0_0, '1']
- [interp_fir_filter_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [interp_fir_filter_xxx_0, '0', wxgui_scopesink2_0, '0']

metadata:
  file_format: 1
