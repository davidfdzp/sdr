options:
  parameters:
    author: Peter Mathys
    category: Custom
    description: Text to PAM
    generate_options: qt_gui
    id: text_pam
    output_language: python
    title: Pulse Amplitude Modulation
  states: {}

blocks:
- name: An
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0'
  states: {}
- name: Glow
  id: variable_qtgui_range
  parameters:
    label: Low-pass filter gain
    orient: Qt.Horizontal
    start: '0.1'
    step: '0.1'
    stop: '100'
    value: '1.8'
  states: {}
- name: M
  id: variable
  parameters:
    value: 2**bits_per_symbol
  states: {}
- name: alpha
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.5'
    stop: '1'
    value: '0.2'
  states: {}
- name: baud_delay
  id: variable_qtgui_range
  parameters:
    label: Baud delay
    min_len: '8'
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '8'
    value: '0'
  states: {}
- name: baud_rate
  id: variable_qtgui_range
  parameters:
    label: Fb
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '8000'
    value: '1000'
  states: {}
- name: bits_per_symbol
  id: variable
  parameters:
    value: '1'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Carrier frequency
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '240000'
    value: '10000'
  states: {}
- name: filter_taps
  id: variable
  parameters:
    value: firdes.low_pass(1,samp_rate,fc,25000, firdes.WIN_HAMMING, 6.76)
  states: {}
- name: lf
  id: variable_qtgui_range
  parameters:
    label: Low-pass filter cut-off frequency
    orient: Qt.Horizontal
    start: '50'
    step: '1'
    stop: samp_rate/2
    value: fc/4
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    label: noise level in [mV]
    orient: Qt.Horizontal
    start: '0'
    step: '1e-3'
    stop: '1'
    value: '0'
  states: {}
- name: polar
  id: variable_qtgui_chooser
  parameters:
    label0: unipolar
    label1: polar
    num_opts: '2'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: ptype
  id: variable_qtgui_chooser
  parameters:
    labels: '["rect", "rcf", "rrcf", "tri", "man", "msin"]'
    num_opts: '0'
    options: '["rect", "rcf", "rrcf", "tri", "man" ,"msin"]'
    type: string
    value: rect
  states: {}
- name: samp_dly
  id: variable_qtgui_range
  parameters:
    comment: Set sample delay to at least 67 for rectangular pulse.
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: sps*8
    value: int(6.7*sps)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: sps
  id: variable
  parameters:
    comment: sps = samp_rate / Fb
    value: int(samp_rate/baud_rate)
  states: {}
- name: tag
  id: variable_tag_object
  parameters:
    key: pmt.intern("Z")
    offset: '0'
    src: pmt.intern("Vsrc")
    value: pmt.intern("0x5a")
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: An
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fc
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /dev/pts/1
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: baud_rate
    type: float
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    tags: '[tag]'
    type: byte
    vector: list(ord(i) for i in 'Zombie')
  states: {}
- name: byte2sym_byte2floatMSB_0
  id: byte2sym_byte2floatMSB
  parameters:
    bit_endianess: '1'
    bits_per_symbol: bits_per_symbol
    bits_to_use_per_byte_mask: '255'
    invert: '0'
    polar: polar
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: noise
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: '1'
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: fec_ber_bf_0
  id: fec_ber_bf
  parameters:
    test_mode: 'False'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
    taps: filter_taps
    type: ccc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: lf
    decim: '1'
    gain: Glow
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {}
- name: pam_xmtr16_ff_0
  id: pam_xmtr16_ff
  parameters:
    a_sps: sps
    b_ptype: ptype
    c_alpha: alpha
    d_k: sps/2
  states: {}
- name: pamrcvr216_ff_0
  id: pamrcvr216_ff
  parameters:
    a_sps: sps
    b_ptype: ptype
    c_alpha: alpha
    d_k: sps/2
    dly: samp_dly
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    min: '0'
    type: float
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: ''
    label2: ''
    marker1: '0'
    nconnections: '2'
    size: '1024'
    srate: samp_rate*sps
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"Z"'
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: sym2byte_float2byteMSB_0
  id: sym2byte_float2byteMSB
  parameters:
    baud_delay: baud_delay
    bit_endianess: '1'
    bits_per_symbol: bits_per_symbol
    bits_to_use_per_byte_mask: '255'
    gain: '1'
    invert: '0'
    polar: polar
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_add_const_vxx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_add_xx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_add_xx_0, '0', qtgui_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_1, '1']
- [blocks_complex_to_mag_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_float_to_complex_1, '0', channels_channel_model_0, '0']
- [blocks_multiply_xx_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_float_to_complex_1, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_throttle_1, '0', pam_xmtr16_ff_0, '0']
- [blocks_vector_source_x_0, '0', byte2sym_byte2floatMSB_0, '0']
- [blocks_vector_source_x_0, '0', fec_ber_bf_0, '0']
- [byte2sym_byte2floatMSB_0, '0', blocks_throttle_1, '0']
- [channels_channel_model_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', low_pass_filter_0, '0']
- [fec_ber_bf_0, '0', qtgui_number_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_mag_0, '0']
- [low_pass_filter_0, '0', pamrcvr216_ff_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_1, '2']
- [pam_xmtr16_ff_0, '0', blocks_add_xx_0, '1']
- [pam_xmtr16_ff_0, '0', blocks_float_to_complex_0, '0']
- [pamrcvr216_ff_0, '0', qtgui_time_sink_x_0, '0']
- [pamrcvr216_ff_0, '1', sym2byte_float2byteMSB_0, '0']
- [pamrcvr216_ff_0, '2', qtgui_time_sink_x_0, '1']
- [sym2byte_float2byteMSB_0, '0', blocks_file_sink_0, '0']
- [sym2byte_float2byteMSB_0, '0', fec_ber_bf_0, '1']

metadata:
  file_format: 1
