options:
  parameters:
    author: Peter Mathys
    category: Custom
    description: Text to PAM
    generate_options: qt_gui
    id: text_pam
    output_language: python
    title: Pulse Amplitude Modulation
  states: {}

blocks:
- name: An
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.32'
  states: {}
- name: M
  id: variable
  parameters:
    value: 2**bits_per_symbol
  states: {}
- name: alpha
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.5'
    stop: '1'
    value: '0.2'
  states: {}
- name: baud_delay
  id: variable_qtgui_range
  parameters:
    label: Baud delay
    min_len: '8'
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '8'
    value: '0'
  states: {}
- name: bits_per_symbol
  id: variable
  parameters:
    value: '1'
  states: {}
- name: polar
  id: variable_qtgui_chooser
  parameters:
    label0: unipolar
    label1: polar
    num_opts: '2'
    option1: '1'
    type: int
    value: '1'
  states: {}
- name: ptype
  id: variable_qtgui_chooser
  parameters:
    label0: rect
    label1: rcf
    num_opts: '2'
    option1: rcf
    type: string
    value: rect
  states: {}
- name: samp_dly
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: sps*8
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '10'
  states: {}
- name: tag
  id: variable_tag_object
  parameters:
    key: pmt.intern("Z")
    offset: '0'
    src: pmt.intern("Vsrc")
    value: pmt.intern("0x5a")
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: An
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: samp_dly
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /dev/pts/1
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    tags: '[tag]'
    type: byte
    vector: list(ord(i) for i in 'Zombie')
  states: {}
- name: byte2sym_byte2floatMSB_0
  id: byte2sym_byte2floatMSB
  parameters:
    bit_endianess: '1'
    bits_per_symbol: bits_per_symbol
    bits_to_use_per_byte_mask: '255'
    invert: '0'
    polar: '1'
  states: {}
- name: fec_ber_bf_0
  id: fec_ber_bf
  parameters:
    test_mode: 'False'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: sps
    taps: '1'
    type: fff
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: sps
    taps: '1'
    type: fff
  states: {}
- name: pam_xmtr16_ff_0
  id: pam_xmtr16_ff
  parameters:
    a_sps: sps
    b_ptype: ptype
    c_alpha: alpha
    d_k: '5'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    min: '0'
    type: float
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate*sps
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: ''
    label2: ''
    marker1: '0'
    nconnections: '2'
    size: '1024'
    srate: samp_rate*sps
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"Z"'
    type: float
  states: {}
- name: sym2byte_float2byteMSB_0
  id: sym2byte_float2byteMSB
  parameters:
    baud_delay: baud_delay
    bit_endianess: '1'
    bits_per_symbol: bits_per_symbol
    bits_to_use_per_byte_mask: '255'
    gain: '1'
    invert: '0'
    polar: polar
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', blocks_delay_0, '0']
- [blocks_add_xx_0, '0', qtgui_sink_x_0, '0']
- [blocks_delay_0, '0', fir_filter_xxx_0, '0']
- [blocks_delay_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', pam_xmtr16_ff_0, '0']
- [blocks_vector_source_x_0, '0', byte2sym_byte2floatMSB_0, '0']
- [blocks_vector_source_x_0, '0', fec_ber_bf_0, '0']
- [byte2sym_byte2floatMSB_0, '0', blocks_throttle_0, '0']
- [fec_ber_bf_0, '0', qtgui_number_sink_0, '0']
- [fir_filter_xxx_0, '0', interp_fir_filter_xxx_0, '0']
- [fir_filter_xxx_0, '0', sym2byte_float2byteMSB_0, '0']
- [interp_fir_filter_xxx_0, '0', qtgui_time_sink_x_0, '1']
- [pam_xmtr16_ff_0, '0', blocks_add_xx_0, '1']
- [sym2byte_float2byteMSB_0, '0', blocks_file_sink_0, '0']
- [sym2byte_float2byteMSB_0, '0', fec_ber_bf_0, '1']

metadata:
  file_format: 1
