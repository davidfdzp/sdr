options:
  parameters:
    author: Peter Mathys
    category: Custom Blocks
    description: Pulse Amplitude Modulation matched filter receiver
    generate_options: hb
    id: pamrcvr216_cc
    output_language: python
    title: PAM Receiver Complex
  states: {}

blocks:
- name: pt_taps
  id: variable
  parameters:
    value: pf.pamhRt(a_sps,b_ptype,[d_k,c_alpha])
  states: {}
- name: a_sps
  id: parameter
  parameters:
    label: Samples/Symbol
    type: intx
    value: '2'
  states: {}
- name: b_ptype
  id: parameter
  parameters:
    label: Pulse type
    type: str
    value: '"rect"'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: dly
    type: complex
  states: {}
- name: c_alpha
  id: parameter
  parameters:
    label: Alpha bandwidth limiting parameter
    type: eng_float
    value: '0.2'
  states: {}
- name: d_k
  id: parameter
  parameters:
    label: Tail length
    type: eng_float
    value: '5'
  states: {}
- name: dly
  id: parameter
  parameters:
    label: Sample delay
    type: intx
    value: '0'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: pt_taps
    type: ccc
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: a_sps
    taps: '1'
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import ptfun as pf
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: a_sps
    taps: '1'
    type: ccc
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: MFout
    type: complex
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_sink_2
  id: pad_sink
  parameters:
    label: samp
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}

connections:
- [blocks_delay_0, '0', fir_filter_xxx_0_0, '0']
- [blocks_delay_0, '0', pad_sink_0, '0']
- [fir_filter_xxx_0, '0', blocks_delay_0, '0']
- [fir_filter_xxx_0_0, '0', interp_fir_filter_xxx_0, '0']
- [fir_filter_xxx_0_0, '0', pad_sink_1, '0']
- [interp_fir_filter_xxx_0, '0', pad_sink_2, '0']
- [pad_source_0, '0', fir_filter_xxx_0, '0']

metadata:
  file_format: 1
