options:
  parameters:
    author: Peter Mathys
    category: Custom Blocks
    description: Conversion from bytes to M-ary symbols
    generate_options: hb
    id: byte2sym_byte2floatLSB
    output_language: python
    title: Byte to Float Symbols LSB first
  states: {}

blocks:
- name: M
  id: variable
  parameters:
    value: 2**a_bpsym
  states: {}
- name: a_bpsym
  id: parameter
  parameters:
    label: Bits per symbol
    type: intx
    value: '2'
  states: {}
- name: bit_endianess
  id: parameter
  parameters:
    label: LSB first
    type: intx
    value: '1'
  states: {}
- name: bits_to_use_per_byte_mask
  id: parameter
  parameters:
    label: Bits to use per byte mask
    type: intx
    value: '255'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-c_pol*(M-1)+(1-c_pol)*0'
    type: float
  states: {}
- name: blocks_and_const_xx_0
  id: blocks_and_const_xx
  parameters:
    const: bits_to_use_per_byte_mask
    type: byte
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: c_pol*0.5+(1-c_pol)
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: a_bpsym
    endianness: gr.GR_LSB_FIRST
    type: byte
  states: {}
- name: c_pol
  id: parameter
  parameters:
    label: Polar
    type: intx
    value: '1'
  states: {}
- name: d_inv
  id: parameter
  parameters:
    label: Invert Bits
    type: intx
    value: '0'
  states: {}
- name: digital_map_bb_1
  id: digital_map_bb
  parameters:
    map: d_inv*list(2**8-1-i for i in range(2**8))+(1-d_inv)*list(range(2**8))
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', pad_sink_0, '0']
- [blocks_and_const_xx_0, '0', digital_map_bb_1, '0']
- [blocks_char_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', blocks_char_to_float_0, '0']
- [digital_map_bb_1, '0', blocks_packed_to_unpacked_xx_0, '0']
- [pad_source_0, '0', blocks_and_const_xx_0, '0']

metadata:
  file_format: 1
