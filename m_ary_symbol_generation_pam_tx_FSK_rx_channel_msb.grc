options:
  parameters:
    author: Peter Mathys
    category: Custom
    description: Text to PAM
    generate_options: qt_gui
    id: text_pam
    output_language: python
    title: Pulse Amplitude Modulation
  states: {}

blocks:
- name: An
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0'
  states: {}
- name: M
  id: variable
  parameters:
    value: 2**bits_per_symbol
  states: {}
- name: alpha
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.5'
    stop: '1'
    value: '0.2'
  states: {}
- name: baud_delay
  id: variable_qtgui_range
  parameters:
    label: Baud delay
    min_len: '8'
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '8'
    value: '0'
  states: {}
- name: baud_delay_fsk
  id: variable_qtgui_range
  parameters:
    label: Baud delay FSK
    min_len: '8'
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '8'
    value: '0'
  states: {}
- name: baud_rate
  id: variable_qtgui_range
  parameters:
    label: Fb
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '8000'
    value: '1000'
  states: {}
- name: bits_per_symbol
  id: variable
  parameters:
    value: '1'
  states: {}
- name: filter_taps
  id: variable
  parameters:
    value: firdes.low_pass(1.0,samp_rate,fsk_deviation_hz,400)
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: highF-lowF
  states: {}
- name: highF
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '1000'
    step: '1'
    stop: '100000'
    value: '2200'
  states: {}
- name: lowF
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '1000'
    step: '1'
    stop: '100000'
    value: '1200'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    label: noise level in [mV]
    orient: Qt.Horizontal
    start: '0'
    step: '1e-3'
    stop: '1'
    value: '0'
  states: {}
- name: polar
  id: variable_qtgui_chooser
  parameters:
    label0: unipolar
    label1: polar
    num_opts: '2'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: ptype
  id: variable_qtgui_chooser
  parameters:
    labels: '["rect", "rcf", "rrcf", "tri", "man", "msin"]'
    num_opts: '0'
    options: '["rect", "rcf", "rrcf", "tri", "man" ,"msin"]'
    type: string
    value: rect
  states: {}
- name: samp_dly
  id: variable_qtgui_range
  parameters:
    comment: Set sample delay to at least 67 for rectangular pulse.
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: sps*8
    value: int(7.04*sps)
  states: {}
- name: samp_dly_fsk
  id: variable_qtgui_range
  parameters:
    comment: Set sample delay to at least 67 for rectangular pulse.
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: sps*8
    value: int(4*sps)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: sps
  id: variable
  parameters:
    comment: sps = samp_rate / Fb
    value: int(samp_rate/baud_rate)
  states: {}
- name: tag
  id: variable_tag_object
  parameters:
    key: pmt.intern("Z")
    offset: '0'
    src: pmt.intern("Vsrc")
    value: pmt.intern("0x5a")
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: An
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: float
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*fsk_deviation_hz/8.0)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: highF
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '2'
    freq: highF
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: lowF
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '-0.5'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_1
  id: blocks_add_const_vxx
  parameters:
    const: '2'
    type: byte
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /dev/pts/0
    type: byte
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /dev/pts/2
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_not_xx_0
  id: blocks_not_xx
  parameters:
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    tags: '[tag]'
    type: byte
    vector: list(ord(i) for i in 'Zombie')
  states: {}
- name: byte2sym_byte2floatMSB_0
  id: byte2sym_byte2floatMSB
  parameters:
    bit_endianess: '1'
    bits_per_symbol: bits_per_symbol
    bits_to_use_per_byte_mask: '255'
    invert: '0'
    polar: polar
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: noise
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: fec_ber_bf_0
  id: fec_ber_bf
  parameters:
    test_mode: 'False'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: (lowF+highF)/2
    decim: '1'
    samp_rate: samp_rate
    taps: filter_taps
    type: fcf
  states: {}
- name: pam_xmtr16_ff_0
  id: pam_xmtr16_ff
  parameters:
    a_sps: sps
    b_ptype: ptype
    c_alpha: alpha
    d_k: sps/2
  states: {}
- name: pamrcvr216_cc_0
  id: pamrcvr216_cc
  parameters:
    a_sps: sps
    b_ptype: ptype
    c_alpha: alpha
    d_k: sps/2
    dly: samp_dly
  states: {}
- name: pamrcvr216_ff_0
  id: pamrcvr216_ff
  parameters:
    a_sps: sps
    b_ptype: rect
    c_alpha: alpha
    d_k: sps/2
    dly: samp_dly_fsk
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    min: '0'
    type: float
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: ''
    label2: ''
    label3: ''
    label4: ''
    marker1: '0'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"Z"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: ''
    label2: ''
    label3: ''
    marker1: '0'
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"Z"'
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    nconnections: '4'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: sym2byte_float2byteMSB_0
  id: sym2byte_float2byteMSB
  parameters:
    baud_delay: baud_delay
    bit_endianess: '1'
    bits_per_symbol: bits_per_symbol
    bits_to_use_per_byte_mask: '255'
    gain: '1'
    invert: '0'
    polar: polar
  states: {}
- name: sym2byte_float2byteMSB_0_0
  id: sym2byte_float2byteMSB
  parameters:
    baud_delay: baud_delay_fsk
    bit_endianess: '1'
    bits_per_symbol: bits_per_symbol
    bits_to_use_per_byte_mask: '255'
    gain: '1'
    invert: '0'
    polar: polar
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_quadrature_demod_cf_0, '0', digital_binary_slicer_fb_0_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_1_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_1, '1']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_0_0, '1']
- [blocks_add_const_vxx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_add_const_vxx_0_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_add_const_vxx_0_1, '0', blocks_char_to_float_0, '0']
- [blocks_add_xx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_add_xx_0, '0', qtgui_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0_0, '2']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_1, '1']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_1_0, '2']
- [blocks_add_xx_0_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_add_xx_0_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_char_to_float_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_1, '2']
- [blocks_char_to_float_0_0, '0', pamrcvr216_ff_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_1, '3']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_1_0, '1']
- [blocks_complex_to_float_0, '0', sym2byte_float2byteMSB_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_float_to_complex_1, '0', channels_channel_model_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_add_xx_0_0, '1']
- [blocks_multiply_xx_1, '0', pamrcvr216_cc_0, '0']
- [blocks_not_xx_0, '0', blocks_add_const_vxx_0_1, '0']
- [blocks_throttle_0, '0', blocks_float_to_complex_1, '0']
- [blocks_vector_source_x_0, '0', byte2sym_byte2floatMSB_0, '0']
- [blocks_vector_source_x_0, '0', fec_ber_bf_0, '0']
- [byte2sym_byte2floatMSB_0, '0', pam_xmtr16_ff_0, '0']
- [channels_channel_model_0, '0', blocks_multiply_xx_1, '0']
- [digital_binary_slicer_fb_0, '0', blocks_not_xx_0, '0']
- [digital_binary_slicer_fb_0_0, '0', blocks_char_to_float_0_0, '0']
- [fec_ber_bf_0, '0', qtgui_number_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_const_sink_x_0_0_0, '0']
- [pam_xmtr16_ff_0, '0', blocks_add_const_vxx_0_0, '0']
- [pam_xmtr16_ff_0, '0', blocks_add_xx_0, '1']
- [pam_xmtr16_ff_0, '0', blocks_float_to_complex_0, '0']
- [pamrcvr216_cc_0, '0', qtgui_time_sink_x_0, '0']
- [pamrcvr216_cc_0, '1', blocks_complex_to_float_0, '0']
- [pamrcvr216_cc_0, '1', qtgui_const_sink_x_0_0, '0']
- [pamrcvr216_cc_0, '2', qtgui_time_sink_x_0, '1']
- [pamrcvr216_ff_0, '0', qtgui_time_sink_x_0_0, '0']
- [pamrcvr216_ff_0, '1', sym2byte_float2byteMSB_0_0, '0']
- [pamrcvr216_ff_0, '2', qtgui_time_sink_x_0_0, '1']
- [sym2byte_float2byteMSB_0, '0', blocks_file_sink_0, '0']
- [sym2byte_float2byteMSB_0, '0', fec_ber_bf_0, '1']
- [sym2byte_float2byteMSB_0_0, '0', blocks_file_sink_0_0, '0']

metadata:
  file_format: 1
