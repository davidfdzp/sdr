options:
  parameters:
    author: Peter Mathys
    category: Custom Blocks
    description: Pulse Amplitude Modulation with different pulses
    generate_options: hb
    id: pam_xmtr16_ff
    output_language: python
    title: PAM transmitter
  states: {}

blocks:
- name: pt_taps
  id: variable
  parameters:
    value: pf.pampt(a_sps,b_ptype,[d_k,c_alpha])
  states: {}
- name: a_sps
  id: parameter
  parameters:
    label: Samples/Symbol
    type: intx
    value: '2'
  states: {}
- name: b_ptype
  id: parameter
  parameters:
    label: Pulse Type
    type: str
    value: rect
  states: {}
- name: c_alpha
  id: parameter
  parameters:
    label: Bandwidth Control Parameter (0<=alpha<=1). Alpha = 0 => sinc pulse
    type: eng_float
    value: '0.2'
  states: {}
- name: d_k
  id: parameter
  parameters:
    label: Tail length k in zero crossings
    type: eng_float
    value: '5'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import ptfun as pf
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: a_sps
    taps: pt_taps
    type: fff
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}

connections:
- [interp_fir_filter_xxx_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', interp_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
