options:
  parameters:
    author: Peter Mathys
    category: Custom
    description: Text to PAM
    generate_options: qt_gui
    id: text_pam
    output_language: python
    title: Pulse Amplitude Modulation
  states: {}

blocks:
- name: M
  id: variable
  parameters:
    value: 2**bits_per_symbol
  states: {}
- name: baud_delay
  id: variable_qtgui_range
  parameters:
    label: Baud delay
    min_len: '8'
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '8'
    value: '0'
  states: {}
- name: bits_per_symbol
  id: variable
  parameters:
    value: '2'
  states: {}
- name: polar
  id: variable_qtgui_chooser
  parameters:
    label0: unipolar
    label1: polar
    num_opts: '2'
    option1: '1'
    type: int
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: tag
  id: variable_tag_object
  parameters:
    key: pmt.intern("Z")
    offset: '0'
    src: pmt.intern("Vsrc")
    value: pmt.intern("0x5a")
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /dev/pts/1
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    tags: '[tag]'
    type: byte
    vector: list(ord(i) for i in 'Zombie')
  states: {}
- name: byte2sym_byte2floatMSB_0
  id: byte2sym_byte2floatMSB
  parameters:
    bit_endianess: '1'
    bits_per_symbol: bits_per_symbol
    bits_to_use_per_byte_mask: '255'
    invert: '0'
    polar: '1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    label1: ''
    marker1: '0'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"Z"'
    type: float
  states: {}
- name: sym2byte_float2byteMSB_0
  id: sym2byte_float2byteMSB
  parameters:
    baud_delay: baud_delay
    bit_endianess: '1'
    bits_per_symbol: bits_per_symbol
    bits_to_use_per_byte_mask: '255'
    gain: '1'
    invert: '0'
    polar: polar
  states: {}

connections:
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', sym2byte_float2byteMSB_0, '0']
- [blocks_vector_source_x_0, '0', byte2sym_byte2floatMSB_0, '0']
- [byte2sym_byte2floatMSB_0, '0', blocks_throttle_0, '0']
- [sym2byte_float2byteMSB_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
