options:
  parameters:
    author: Peter Mathys
    category: Custom Blocks
    description: Converts float symbols to bytes with LSB first
    generate_options: hb
    id: sym2byte_float2byteLSB
    output_language: python
    title: Float Symbols to Bytes LSB First
  states: {}

blocks:
- name: M
  id: variable
  parameters:
    value: 2**bits_per_symbol
  states: {}
- name: baud_delay
  id: parameter
  parameters:
    label: Symbols delay
    type: intx
    value: '0'
  states: {}
- name: bit_endianess
  id: parameter
  parameters:
    label: LSB first
    type: intx
    value: '1'
  states: {}
- name: bits_per_symbol
  id: parameter
  parameters:
    label: Bits per Symbol
    value: '2'
  states: {}
- name: bits_to_use_per_byte_mask
  id: parameter
  parameters:
    label: Bits to use per byte mask
    type: intx
    value: '255'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: polar*(M-1)+(1-polar)*0
    type: float
  states: {}
- name: blocks_and_const_xx_0
  id: blocks_and_const_xx
  parameters:
    const: bits_to_use_per_byte_mask
    type: byte
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: baud_delay
    type: byte
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: polar*0.5+(1-polar)
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain
    type: float
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: bits_per_symbol
    endianness: gr.GR_LSB_FIRST
    type: byte
  states: {}
- name: digital_map_bb_1
  id: digital_map_bb
  parameters:
    map: invert*list(2**8-1-i for i in range(2**8))+(1-invert)*list(range(2**8))
  states: {}
- name: gain
  id: parameter
  parameters:
    label: Gain
    type: eng_float
    value: '1'
  states: {}
- name: invert
  id: parameter
  parameters:
    label: Invert Bits
    type: intx
    value: '0'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}
- name: polar
  id: parameter
  parameters:
    label: Polar
    type: intx
    value: '1'
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_float_to_char_0, '0']
- [blocks_and_const_xx_0, '0', pad_sink_0, '0']
- [blocks_delay_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [blocks_float_to_char_0, '0', blocks_delay_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', digital_map_bb_1, '0']
- [digital_map_bb_1, '0', blocks_and_const_xx_0, '0']
- [pad_source_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
